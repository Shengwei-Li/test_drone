# Repository Shengwei-Li/test_drone

File README.md:

# 自研微型四旋翼

目标:从零设计一架 1S 微型四旋翼(自研飞控板),并在上面跑串级 PID、几何控制、INDI、MPC 和强化学习。

## 现状:第 1 阶段,仿真

```
sim/params.py      机体参数(目前是 Crazyflie 2.x 的占位值)
sim/dynamics.py    6 自由度刚体 + 电机一阶滞后,RK4
sim/controller.py  四种控制器:串级 PID、几何控制、INDI、MPC+INDI
sim/mpc.py         线性 MPC 求解器(ADMM + 预算 Riccati 增益,TinyMPC 的做法)
compare_controllers.py  各控制器在两条轨迹、标称/扰动场景下的对比表
rl/                强化学习:批量并行环境 (env.py)、PPO 训练 (train.py)、训练好的策略 (policy.npz)
sim/rl_policy.py   策略的部署端(纯 numpy 前向计算)
recovery.py        "抛飞恢复"测试:各控制器从大角度翻滚状态恢复的成功率
firmware/core/     固件核心库(C99):ESKF、几何控制/INDI、策略网络推理,不依赖任何芯片
firmware/sil.py    软件在环:把编译好的 C 库接进仿真(build.py 编译,bench.py 估算运算量)
mech/model.py      机架的参数化模型:零件清单 → 质量、重心、惯量 → 仿真参数
hardware/          飞控板 V1 原理图(脚本生成,见 hardware/README.md)
sim/sensors.py     传感器模型:IMU、ToF、光流(带噪声和零偏)
sim/estimator.py   15 维误差状态卡尔曼滤波器 (ESKF)
run_demo.py        起飞悬停 + 8 字轨迹跟踪(加 --est 则控制器只用估计值)
visualize.py       生成 3D 回放 out/replay.html(同样支持 --est)
viz/               回放页面模板(three.js)
tests/             动力学和闭环的基本检查
```

运行:

```
python -m pytest -q tests
python run_demo.py
python visualize.py
```

依赖 numpy(测试还用到 scipy);装了 matplotlib 会额外输出 `out/demo.png`。
强化学习的训练需要 PyTorch(有 GPU 更快);只运行训练好的策略不需要。
`out/replay.html` 直接用浏览器打开即可(需要联网加载 three.js):可拖动视角、暂停、拖进度条、调速度。

## 约定

- 世界系 ENU(z 向上),机体系 FLU(x 前、y 左、z 上)。
- 四元数 `[w, x, y, z]`,机体系到世界系。
- 状态 17 维:位置、速度(世界系)、四元数、角速度(机体系)、4 个电机转速。
- 电机编号:M1 右前、M2 右后、M3 左后、M4 左前。

## 仿真里还没有的东西

- 传感器延迟、异常值,气压计和磁力计。
- 真实的地面接触(现在只是把机体"粘"在地上,没有弹跳、摩擦、翻倒)、地面效应、电池压降。
- 混控饱和时的优先级处理(现在只是限幅)。

## 基线

同一条 8 字轨迹(幅值 0.5 m,角频率 1.5 rad/s),串级 PID:

| 控制器看到的状态 | 跟踪 RMS 误差 |
|---|---|
| 真值(`python run_demo.py`) | 约 9 cm |
| ESKF 估计值(`--est`,3 个随机种子) | 约 14 cm |

后面每换一种控制或估计算法,都用这两个数字对比。

## 控制器对比

`python compare_controllers.py`(加 `--est` 则用估计值)。同一条 8 字轨迹,跟踪 RMS 误差:

| 控制器 | 标称(真值) | 扰动(真值) | 标称(估计) | 扰动(估计) |
|---|---|---|---|---|
| 串级 PID | 9.2 cm | 16.1 cm | 14.0 cm | 25.0 cm |
| 几何控制 | 3.6 cm | 55.9 cm | 11.6 cm | 53.4 cm |
| INDI | 0.8 cm | 2.6 cm | 10.8 cm | 15.3 cm |
| MPC+INDI | 0.6 cm | 0.9 cm | 14.7 cm | 10.7 cm |
| 强化学习 | 3.8 cm | 5.0 cm | 13.9 cm | 11.9 cm |

扰动场景:真实机体比模型重 10%、1 号电机弱 10%,8 s 起有 0.03 N 侧风(约 11% 机重)。
控制器和估计器始终只知道标称模型。估计列是 3 个随机种子的平均。

- **几何控制**靠前馈(由轨迹的 jerk 算期望角速度)把标称误差从 9 cm 降到 3.6 cm,
  但没有积分项,遇到恒定扰动会留下很大的稳态误差。
- **INDI** 用陀螺导数和加速度计直接"量出"扰动并抵消,不依赖积分慢慢补,
  标称和扰动场景都是最好的。
- 用估计值时,三者的真实跟踪误差都被水平位置漂移(约 10 cm)垫高。
  相对"估计位置"的误差:INDI 4.1 / 4.7 cm,PID 10.4 / 16.6 cm,这才反映控制器本身。
- 扰动场景下估计漂移在这 3 个种子里偏大,样本太少,还没确认是不是系统性的。

- **MPC+INDI**:位置层用线性 MPC 规划(每轴三重积分器,看未来 1 s,50 Hz 重算),
  姿态和抗扰交给 INDI。它只拿到未来的参考位置,没有解析前馈,8 字误差仍与 INDI 相当。
  用估计值时相对"估计位置"的误差是 2.7 / 3.1 cm;真实误差同样被估计漂移垫高,
  3 个种子下与 INDI 互有高低,不能说谁更好。

航点轨迹(参考位置每 2.5 s 跳 1 m,没有任何前馈),跟踪 RMS 误差:

| 控制器 | 标称(真值) | 扰动(真值) | 标称(估计) | 扰动(估计) |
|---|---|---|---|---|
| 串级 PID | 48.0 cm | 52.0 cm | 48.7 cm | 57.1 cm |
| 几何控制 | 46.3 cm | 76.1 cm | 47.1 cm | 76.5 cm |
| INDI | 45.9 cm | 46.4 cm | 46.9 cm | 51.0 cm |
| MPC+INDI | 14.0 cm | 15.2 cm | 20.6 cm | 19.7 cm |
| 强化学习 | 38.5 cm | 39.9 cm | 41.0 cm | 41.4 cm |

跳变的参考本来就不可能零误差跟上。MPC 的优势是能提前看到跳变并提前动作,
而且速度、加速度、jerk 的限制是规划时就考虑的(每轴速度上限 2 m/s)。
其余三种只能等误差出现后再追。

MPC 目前的局限:模型是悬停附近的线性点质量模型,没有包含姿态动力学和推力上限;
每次固定迭代 10 轮,没有检查收敛;Python 里每次求解约 7 ms,还没测单片机上的耗时。

单独运行某个控制器:`python run_demo.py --ctrl mpc --traj waypoints --disturb [--est]`,
`visualize.py` 支持同样的参数。

## 强化学习

`python -m rl.train` 用 PPO 训练一个端到端策略:输入 28 维观测(位置/速度误差、参考加速度、
旋转矩阵、角速度、上一次动作、位置误差积分),直接输出四个电机的转速指令,100 Hz。
策略网络是 28→64→64→4 的全连接网络,约 6000 个参数。

- 训练在 4096 个并行环境里进行(PyTorch,GPU),约 5200 万步,RTX 5060 上用时约 4 分钟。
- 每个环境的质量、惯量(±20%)、各电机强度(±15%)、电机响应(±30%)和风都随机,
  参考点静止或沿随机正弦轨迹运动;10% 的回合从任意姿态开始。
- 训练环境用 1 ms 欧拉积分、没有地面;评估全部在原来的仿真里做(RK4、有地面、从地面起飞)。
  策略没有见过评估用的 8 字和航点轨迹,也没有见过地面。

结果(见上面两张表和下面的恢复测试):

- 8 字跟踪 3.8 cm,与几何控制相当,不如 INDI 和 MPC;但扰动场景只退化到 5.0 cm,
  远好于几何控制的 55.9 cm —— 域随机化加上"位置误差积分"这个输入起了作用。
- 航点 38.5 cm,比 PID/INDI 略好(动作更激进,倾角到 55°–60°),不如能预瞄的 MPC。
- 第一版观测里没有参考加速度,8 字误差是 10.5 cm;加上之后降到 3.8 cm。

抛飞恢复(`python recovery.py`):从倾斜 90°–180°、角速度最高约 10 rad/s 的状态开始,
3 秒内稳回悬停点算成功,100 次随机试验:

| 控制器 | 成功率 | 成功时平均掉高 |
|---|---|---|
| 串级 PID | 45% | 0.64 m |
| 几何控制 | 57% | 1.30 m |
| INDI | 54% | 1.33 m |
| MPC+INDI | 50% | 1.28 m |
| 强化学习 | 76% | 0.52 m |

这是强化学习最明显的优势。要说明的是,其余几种控制器的参数都是为正常飞行调的,
没有针对翻转恢复做过任何设计(比如倒置时先关推力),所以这个对比对它们不算公平。

局限:只训练了一个随机种子,没有做多种子的重复性检查;训练时的观测噪声比 ESKF 的
实际误差小,也没有模拟传感器延迟;策略是否在定点运算或单精度下保持性能还没验证。

## 固件核心库与软件在环

`firmware/core/` 是将来要烧进 STM32 的那部分代码:标准 C99,不分配内存,不碰任何外设。
目前有三块,都是对照 Python 版本逐行改写的:

| 文件 | 内容 | 对应的 Python |
|---|---|---|
| `fc_eskf.c` | 15 维 ESKF:IMU 预测、测距/光流更新、陀螺零偏校准 | `sim/estimator.py` |
| `fc_ctrl.c` | 几何控制、INDI、混控 | `sim/controller.py` |
| `fc_policy.c` | 强化学习策略的网络推理 | `sim/rl_policy.py` |
| `fc_mpc.c` | 位置层 MPC(每轴一个 3 状态问题,查增益表) | `sim/mpc.py` |
| `fc_proto.c` | 串口协议:组帧、CRC16、逐字节解析 | `firmware/proto.py`(地面端) |
| `fc_fsm.c` | 飞行状态机和安全逻辑 | 无(只有 C 版) |
| `fc_app.c` | 主循环:把以上各块串起来 | 无(只有 C 版) |

软件在环:`python run_demo.py --ctrl indi --est --fw f32`。加 `--fw` 后,仿真里的估计器和
控制器换成编译好的 C 代码,物理和传感器模型不变。`f32` 是单精度(与 STM32F4 的硬件浮点一致),
`f64` 是双精度(用来和 Python 逐位对照)。

整段 15 秒闭环飞行(扰动场景)与 Python 版本的轨迹最大偏差:

| 配置 | 双精度 | 单精度 |
|---|---|---|
| INDI + ESKF | 9×10⁻¹⁵ m | 5.5 µm |
| 强化学习 + ESKF | 6×10⁻¹⁵ m | 4.5 µm |
| INDI(真值状态) | 9×10⁻¹⁶ m | 0.7 µm |

双精度一致到舍入误差,说明改写没有引入错误;单精度的偏差在微米量级,
协方差矩阵保持对称正定,说明 15 维 ESKF 用单精度是够的。

运算量(`python -m firmware.bench`)。STM32 的数字是按乘加次数估的,不是实测
(假设每次乘加连同循环开销 10 个时钟周期,主频 168 MHz):

| 函数 | 频率 | 估算耗时 | 估算 CPU 占用 |
|---|---|---|---|
| ESKF 预测 | 500 Hz | 约 0.41 ms | 21% |
| ESKF 光流更新 | 100 Hz | 约 0.51 ms | 5% |
| ESKF 测距更新 | 50 Hz | 约 0.46 ms | 2% |
| INDI 控制器 | 500 Hz | 约 0.02 ms | 1% |
| 策略网络推理 | 100 Hz | 约 0.59 ms | 6% |

合计约 35%。大头是 ESKF 的协方差传播,现在是 15×15 的稠密矩阵乘法;转移矩阵大部分是 0,
利用稀疏性可以省掉大半。状态占 RAM 约 1.4 KB,ESKF 的中间矩阵另占约 3.6 KB,策略权重 24.5 KB 可放 Flash。

MPC 的 C 版本与 Python 的闭环轨迹偏差:双精度 10⁻¹⁵ m,单精度约 1 µm。按乘加次数估算,
每次求解约 1.8 ms(50 Hz,占 CPU 约 9%)。

### 整机软件在环

`python -m firmware.app_sim`。这里跑的是完整的固件主循环 `fc_app_step`:仿真只扮演物理世界、
传感器和地面站,解锁、目标点、降落全部通过协议帧发给固件。固件自己完成陀螺校准、
解锁自检、飞行、降落和故障处理。

状态机:上锁 → 飞行 → 降落 → 上锁;翻倒或估计器失效时进入故障(电机停转,需上锁指令清除)。

| 场景 | 固件的反应 |
|---|---|
| 正常飞行 | 1.0 s 解锁,跟 8 字(误差 16.4 cm),14.0 s 收到降落指令,17.5 s 触地上锁 |
| 8.0 s 链路丢失 | 8.48 s 判定丢失并原地降落,11.9 s 触地上锁 |
| 8.0 s 电压跌到 3.2 V | 持续 1 s 后(9.0 s)开始降落,12.4 s 触地上锁 |
| 链路有 1% 位错误和乱码 | 坏帧被丢弃,飞行和降落不受影响 |
| 解锁后翻倒超过 0.5 s | 进入故障,电机停转 |
| 未校准或电压不足时解锁 | 拒绝解锁 |

正常飞行的 16.4 cm 比前面表里的 INDI 大,是因为协议里的目标点只带位置、速度、加速度,
没有 jerk 前馈,而且这是用估计值飞的。

协议有两份独立实现(C 和 Python),互相能解出对方的帧。测试过程中发现并修掉了 C 解析器的
一个缺陷:乱码里碰巧出现帧头字节时,会连带丢掉紧跟着的一帧好数据。

还没做的:
- 传感器和电机的驱动、调度。没有硬件只能写,不能验证。
- 日志和参数存储、通过 USB 升级。
- 主循环里只接了 INDI 和强化学习策略,MPC 还没接(它需要地面把未来一段轨迹发上来,协议里还没有这种帧)。
- 上锁状态下估计器不运行,解锁时假定机体水平静止在原点。
- 降落靠估计高度判断触地;真实地面附近测距有盲区,这个判据没有在真实传感器上验证过。
- 核心库只在电脑上用 MSVC 编译过,还没用 ARM 编译器编过。

## 机架模型

`python -m mech.model`。方案是 PCB 本身当机架(Crazyflie 的做法):中间 40 mm 见方的主板,
四条 7 mm 宽的臂从四角伸出,电机轴在离中心 48 mm 处(对角距 96 mm);电池在板子下方。
臂的末端是一段插舌,插进 3D 打印的电机座(`python -m mech.motor_mount` 生成 STL),
电机座套住电机并向下伸出当脚架,用一根 1 mm 钢丝穿过定位孔锁住。
所有尺寸和零件质量都写在 `mech/model.py` 开头,改完重新运行即可。

| 量 | 本设计 | 原占位值(Crazyflie) |
|---|---|---|
| 质量 | 34.2 g | 27.0 g |
| 臂长(中心到电机) | 48.0 mm | 39.7 mm |
| 惯量 Jx / Jy / Jz(10⁻⁵ kg·m²) | 2.02 / 2.03 / 3.89 | 1.40 / 1.40 / 2.17 |
| 推重比 | 1.78 | 2.25 |

质量预算:电机 10.8 g、电池 7.5 g、PCB 4.4 g、板上元件约 4.7 g、电机座 2.9 g、
外接光流/测距模块 2.0 g(预留)、桨 1.0 g、导线绑带 1.0 g。

脚本会自动解出让重心前后位置为零的电池位置。光流和测距用外接的现成模块(型号未定),
装在电池正下方,预留 30 × 36 × 5 mm;脚架因此加长到板下 16 mm。重心比电机平面低 2.7 mm。

换成这套参数后(各命令加 `--design`),所有控制器不重调、强化学习策略不重训,
跟踪误差与原参数基本一样:8 字标称 PID 10.2、几何 2.9、INDI 0.7、MPC 0.6、强化学习 4.0 cm。
这就是"先用占位参数做算法,再迁移到真实机架"的验证:迁移只是换一组数字。

整机装配:`python -m mech.assembly` 把 KiCad 导出的 PCB 三维模型(带元件)、电机座、电机、桨、
电池、光流子板拼到一起,生成 `out/assembly.html`(浏览器里可旋转、可看爆炸视图),
并按 PCB 的实际摆位做干涉和配合检查。板上主要元件的位置也按实际摆位回填进了质量模型。
目前 11 项检查全部通过;做这一步时查出并改掉了一处干涉(底面的子板接口伸到电池下方约 1.7 mm)。

实体 CAD:`python -m mech.cad`(需要 build123d)。它把电机座做成一个完整的实体并导出
`mech/out/motor_mount.step` 和 `.stl`(打印用这个),把整机装配导出成 `out/assembly.step`
(可以用 Fusion 360 或 FreeCAD 打开),并做真正的实体干涉检查:电机座、电机、桨、电池、光流子板
逐个与 PCB 模型的 116 个实体(板子和每个元件)做布尔求交,目前全部无干涉。
这个检查验证过能抓到问题:故意把电池抬高 1.5 mm,它报出 299 mm³ 的相交体积。

要注意的:
- 零件质量大多是估计值(ESP32 模块、连接器、电机座、焊锡等),没有实物称重。
- 电机最大推力沿用 Crazyflie 的量级(每个 0.149 N),不是所选电机的实测值;
  推重比 1.78 偏低(最初的占位值是 2.25,加板子、电机座、外接模块后一路下降),激进机动的余量不大。
- 板厚 1.0 mm、臂宽 7 mm 的 PCB 臂的刚度和振动频率没有校核,太软会把振动传给 IMU。
- 电机座没有打印验证过,电机孔、插槽、销孔的配合间隙大概率要试打一两次再调。
- 桨盘(46 mm)在俯视方向与臂根有重叠,会损失一点推力;ESP32 天线端伸出板前沿约 6 mm。
- 仿真假设推力作用在重心平面、惯量张量是对角的;实际非对角项约 0.5%,影响很小。

## 状态估计的现状

流程:先在地面静止 1 s 校准陀螺零偏,然后起飞。带噪声闭环飞 15 s(3 个随机种子):

| 量 | 未校准(`--no-calib`) | 校准后 |
|---|---|---|
| 偏航漂移(结束时) | 4–14° | 0.4–1.1° |
| 速度 RMS | 5.5–12.8 cm/s | 约 5 cm/s |
| 倾斜方向 RMS | 1.0–1.7° | 0.3–1.2° |
| 高度 RMS | 约 0.35 cm | 约 0.35 cm |
| 水平位置漂移(结束时) | 5–14 cm | 5–13 cm |
| 8 字跟踪 RMS | 14–15 cm | 约 14 cm |

校准压住了偏航漂移,但跟踪误差几乎没变。剩下的误差来自**水平位置漂移**:
光流只给速度,位置靠积分,速度里的白噪声积出来就是随机游走
(默认噪声 0.3 rad/s、100 Hz、1 m 高度下,约 3 cm/√s,15 s 约 12 cm)。
对照实验:把光流噪声降到 0.03 rad/s,跟踪误差回到 9–10 cm,与真值基线一致。

所以这是"光流 + ToF"方案本身的上限,不是滤波器的缺陷。要去掉它,需要一个水平位置
的绝对参考(外部定位、视觉里程计的回环等);默认的 0.3 rad/s 也是偏保守的猜测,
等有了实测数据再定。

## 参考的开源项目

| 项目 | 参考什么 |
|---|---|
| Crazyflie firmware(Bitcraze) | 微型机固件架构、估计器、控制器 |
| ESP-Drone(乐鑫) | 低成本硬件方案 |
| gym-pybullet-drones | Crazyflie 参数、RL 环境接口 |
| RotorPy | 自写 Python 仿真的结构、气动模型 |
| rl-tools / Learning to Fly in Seconds | 端到端 RL 与 sim2real |
| TinyMPC | 单片机上的 MPC |
| PX4、Betaflight | 滤波、混控、工程细节 |

## 路线(全程不需要硬件,硬件放最后)

1. ✅ 动力学仿真、串级 PID 基线、3D 回放。
2. ✅ 传感器模型(IMU、光流、ToF)和 ESKF 状态估计。
   已有简易地面模型和上电陀螺校准。待补:传感器延迟、水平位置与偏航的绝对参考。
3. ✅ 高级控制:几何控制、INDI、MPC(位置层线性 MPC + INDI 内环)。
   待补:包含姿态和推力约束的非线性 MPC。
4. ✅ 强化学习:并行环境、PPO 训练、域随机化,端到端策略已能在原仿真里飞。
   待补:多种子重复、把估计误差和延迟放进训练、与真机参数对齐后重训。
5. 固件:✅ 估计、控制(INDI/MPC/策略网络)、通信协议、状态机和主循环的 C 库,
   整机软件在环通过。待补:驱动层、调度、日志和参数存储;用 ARM 编译器编译并在
   MCU 仿真器(如 Renode)上跑。
6. 机械模型:✅ 参数化机架模型(质量、重心、惯量、板子外形),可用 `--design` 代入仿真。
   待补:可加工的 3D 模型(电机座等打印件)、臂的刚度校核、实物称重回填。
7. 电路板:KiCad 原理图和 4 层板,做到规则检查通过、可以直接下单的程度。
   原理图 V1 已对照数据手册核对并修改;PCB 已生成板框和全部元件的摆位(`hardware/`),
   走线和铺铜未做。
8. 用 MuJoCo 做一次交叉验证。
9. (最后)打板、买料、装机、系统辨识、实飞。

没有实机之前,仿真和真实世界的差距没法测量。所以第 2、4 步要把噪声、延迟和参数
误差的范围设得偏保守,让算法在一族模型上都能工作,而不是只在标称模型上。

## KiCad design hardware/fc_v1/fc_v1.kicad_pcb

File hardware/README.md:

# 飞控板 V1:原理图和 PCB 摆位

1S 锂电、有刷空心杯电机的微型四旋翼飞控,PCB 本身就是机架。原理图和 PCB 都由脚本生成:

```bash
python hardware/fc_v1.py
```

```bash
D:\kicad\bin\python.exe hardware\pcb_gen.py
```

第二条必须用 KiCad 自带的 Python(要用它的 pcbnew 模块),并且要先运行过第一条和 `python -m mech.model`。

- [fc_v1.py](fc_v1.py):原理图的设计本身 —— 每个器件和它的"引脚 → 网络"表。
- [pcb_gen.py](pcb_gen.py):PCB 的摆位表(每个封装的坐标、角度、正反面)和网络分类。
- [schgen.py](schgen.py)、[sexpr.py](sexpr.py):原理图生成器。
- `fc_v1/fc_v1.kicad_sch`、`fc_v1.kicad_pcb`、`fc_v1.kicad_pro`:生成的工程,可直接用 KiCad 10 打开。
- `fc_v1/render_top.png`、`render_bottom.png`:3D 渲染图;`placement_top.pdf`、`placement_bottom.pdf`:摆位图。
- `fc_v1/erc.rpt`、`drc.json`:电气规则和设计规则检查报告。

**重要**:PCB 文件现在只有板框、封装和飞线,没有走线和铺铜。开始布线之后就不要再运行 `pcb_gen.py`,
它会把整块板子重新生成、覆盖掉走线。之后改原理图请用 KiCad 的"从原理图更新 PCB"(封装已经和原理图符号关联好)。

## 器件选型

| 功能 | 器件 | 说明 |
|---|---|---|
| 主控 | STM32F405RGT6 | 168 MHz、带 FPU |
| IMU | BMI088 | Crazyflie 2.1 同款,抗振动好 |
| 气压计 | BMP280 | I2C,地址 0x76 |
| 无线 | ESP32-C3-WROOM-02 | 串口桥,天线伸出板前沿 |
| 日志 | W25Q128JV | 16 MB SPI Flash |
| 电源 | TPS63001 | 升降压,电池 3.0–4.2 V 全程输出 3.3 V |
| 充电 | MCP73831-2 | USB 充电,约 256 mA |
| 电机驱动 | AO3400A ×4 | 低边 N-MOS + 肖特基续流 + 栅极下拉,放在臂上 |
| 光流 + 测距 | 外接现成模块(型号未定) | 主板留两个接口,见下 |
| 5 V 升压 | TPS61222 | 只给串口类模块供电,默认关闭 |

## 外接光流/测距模块的接口

光流和测距不在主板上,也不自己做子板,用外接的现成模块。型号还没定,所以两类常见模块的接口都留了:

| 接口 | 针脚 | 适用的模块 |
|---|---|---|
| J9(8 针,底面前右) | 3.3 V、SCK、MISO、MOSI、片选、SCL、SDA、地 | SPI + I2C 这一类,例如 Bitcraze Flow deck v2 |
| J10(4 针,底面前左) | 5 V、TX、RX、地 | 串口这一类,例如 Matek 3901-L0X、MicoAir MTF-01 |

- J9 的三根 SPI 线各串了 33 Ω。SPI2 和板上的 Flash 共用,串电阻后外接线缆不直接挂在 Flash 的总线上。
- J10 的串口是 UART5(PC12 发、PD2 收),电平 3.3 V,不占用扩展口的串口,也不是自带下载程序会监听的引脚。
- 5 V 由 TPS61222 从电池升压得到,使能脚接 PB10 并下拉,默认关闭。它的引脚和典型电路对照 TI 手册核对过
  (1 VIN、2 FB 接 VOUT、3 地、4 VOUT、5 电感、6 使能;4.7 µH,输入输出各 10 µF)。
- 5 V 的带载能力有限:开关电流限制最小 200 mA,从 3 V 升到 5 V 时可靠输出只有几十毫安。
  Matek 模块标称 40 mA,够用;其他模块要先查它的耗电。
- 升压芯片关闭时输出不是 0 V,而是接近电池电压。
- Flow deck v2 的原理图我读过:它要 3 V 主电源、给板上 1.8 V 稳压器的输入电源、SPI、I2C 和地,
  两路电源都接 J9 的 3.3 V 即可。它的插针是 Crazyflie 的排针,需要做一根转接线。

模块装在电池正下方,机械上预留了 30 × 36 × 5 mm。MicoAir MTF-01 高 14.5 mm,放不进这个空间。

## STM32 引脚分配

| 引脚 | 功能 | 引脚 | 功能 |
|---|---|---|---|
| PC6–PC9 | 电机 1–4 PWM(TIM3 CH1–4) | PA5/PA6/PA7 | SPI1:IMU |
| PA4 / PC4 | IMU 片选(加速度计 / 陀螺) | PC5 / PB0 | IMU 中断(加速度计 / 陀螺) |
| PB13/PB14/PB15 | SPI2:Flash + 光流 | PB12 / PC0 | Flash 片选 / 光流片选 |
| PB6 / PB7 | I2C1:气压计 + 测距 + 扩展口 | PA2 / PA3 | USART2:ESP32-C3 |
| PC3 / PA8 | ESP32 使能 / 启动模式 | PA0 / PA1 | UART4:扩展口 |
| PA11 / PA12 | USB D− / D+ | PA9 | USB VBUS 检测(当普通输入读) |
| PA13 / PA14 / PB3 | SWD:SWDIO / SWCLK / SWO | PC2 | 电池电压 ADC(通道 12) |
| PB4 / PB5 | LED | PB1 | 扩展口备用 IO |
| PC12 / PD2 | UART5:串口类光流模块 | PB10 | 5 V 升压使能 |

以上复用功能都对照 STM32F405 数据手册的复用表核对过。

## 对照数据手册的核对结果

查的是各厂家的官方数据手册(TI、Microchip、AOS、ST、Espressif、Winbond、Bosch、PixArt)。
ST 官网当时打不开,STM32 的资料读的是镜像站上较旧的版本(数据手册 Rev 8、AN2606 Rev 61)。

核对后改动的地方:

| 位置 | 改动 | 依据 |
|---|---|---|
| TPS63001 | VINA 经 100 Ω + 100 nF 滤波;使能和 PS/SYNC 改接 VINA | 手册典型应用电路 |
| STM32 | VBAT 脚加专用 100 nF | AN4488 |
| STM32 | PA10 加 10 kΩ 下拉 | 它是自带下载程序的串口输入,不能悬空 |
| BMP280 | VDD 和 VDDIO 各一个 100 nF(原来共用一个) | 手册参考电路 |
| Flash | 片选加 10 kΩ 上拉;WP、HOLD 由直连 3.3 V 改为 10 kΩ 上拉 | 片选须随电源上电;IQ 型号这两脚可能成为输出 |
| ESP32-C3 | IO9 加 10 kΩ 上拉 | 硬件设计指南 |
| 晶振 | 指定负载电容 10 pF 的型号(配 12 pF) | 12 pF 只适合负载电容约 10 pF 的晶振 |

核对后确认不用改的:TPS63001 的 FB、电感、输入输出电容;MCP73831 的电容、充电电流、指示灯接法;
AO3400A 的引脚和 3.3 V 直接驱动;USB-C 的两个 5.1 kΩ;STM32 的 VCAP、去耦、复位、启动脚;
BMI088 的全部接法(包括两个 SDO 接在一起);ESP32-C3 的使能 RC 和启动配置脚。

使用上的约束(不是电路改动):

- **充电时要把电源开关拨到关**。充电芯片靠电流降到约 19 mA 来判断充满,系统开着耗电的话可能永远不结束。
- **3.3 V 电源在电池低压时最多按 800 mA 设计**。无线模块发射峰值约 345 mA,够用。
- **固件里要关掉 USB 的硬件 VBUS 检测**,把 PA9 当普通输入读。
- **BMI088 的加速度计上电默认是 I2C 模式**,固件要先对它的片选做一次空读才进入 SPI。

没有核实到一手资料的:晶振的驱动电平和是否需要串联电阻(要看所买晶振的手册);
USB-C 的 5.1 kΩ 只查到厂商应用笔记,没查到 USB-IF 的规范原文;STM32 资料不是最新版。

ERC 现在剩 1 个错误、1 个警告,都是有意的接法(BMI088 两个输出相连;BMP280 的 SDO 直接接地选地址)。

## PCB 摆位

板子:中间 40 mm 见方,四条 7 mm 宽的臂,电机对角距 96 mm,4 层,板厚 1.0 mm。
臂的末端是一段 7 mm 宽的插舌,上面有两个 1.1 mm 的定位孔,插进 3D 打印的电机座
(模型由 `python -m mech.motor_mount` 生成,在 `mech/out/motor_mount.stl`)。电机本身不碰 PCB。
顶面 80 个元件全部可以机器贴片;底面只有 3 个接口。

| 区域 | 放了什么 | 为什么 |
|---|---|---|
| 最前 | 无线模块,天线伸出板边约 6 mm | 天线下方和两侧没有板子和铜,这是厂家推荐做法 |
| 正中 | IMU | 离四个电机等距,板子弯曲应力最小;手册要求它下方顶层不走线、不打孔 |
| 中后 | 主控(转了 180°) | 转过来后 IMU 的 SPI 脚朝前、USB 脚朝左、晶振脚朝右,各自正对要连的器件 |
| 后右 | 升降压电源、电感、开关、电池电压检测 | 开关电源离天线最远,也不挨着 IMU |
| 后左 | USB-C(开口朝左)、充电芯片 | USB 的两根信号线到主控只有约 5 mm |
| 前左 / 前右 | Flash / BOOT 键和指示灯 | 填在无线模块两侧 |
| 四条臂 | MOS 管、续流二极管、下拉电阻、电机线焊孔 | 每个电机的大电流回路只在自己的臂上,不进板子中心 |
| 臂末端 | 插舌和定位孔(没有元件) | 离中心 38.5 mm 以外的部分会被电机座包住 |
| 左侧中部 | 5 V 升压 | 离 IMU 约 16 mm,离天线和晶振也远 |
| 底面 | 两个模块接口(前左、前右)、扩展口和调试口(后) | 让开中间的电池位置 |

网络分类(写在工程文件里,布线时自动生效):

| 分类 | 线宽 | 间距 | 过孔 | 包含 |
|---|---|---|---|---|
| Default | 0.15 mm | 0.15 mm | 0.6 / 0.3 mm | 普通信号 |
| Power | 0.4 mm | 0.15 mm | 0.6 / 0.3 mm | 3.3 V、VBUS、开关电源的电感两端 |
| Motor | 1.0 mm | 0.2 mm | 0.8 / 0.4 mm | 电池正极、电机负端 |

设计规则检查(未布线状态):元件之间没有干涉,没有焊盘离板边过近。还有三类提示没处理:

- 无线模块封装自带 12 个 0.2 mm 的散热过孔,小于默认的 0.3 mm 最小孔径。下单前确认板厂支持,或改规则。
- 约 120 条丝印重叠或压焊盘的提示。丝印还没整理。
- 241 条飞线未连接。这是正常的,因为还没布线。

## 摆位复核(按引脚距离,不只看干涉)

第一版摆位只检查了元件之间有没有干涉,被指出 5 处问题后逐项改了,并把所有去耦电容到目标引脚的距离量了一遍:

| 位置 | 改之前 | 现在 |
|---|---|---|
| VCAP 电容 C17 / C18 到 31 / 47 脚 | 13.5 / 6.5 mm | 2.2 / 2.1 mm |
| 晶振负载电容 | 两个放反,走线要交叉 | 各自在对应焊盘一侧,2.3 / 2.4 mm |
| 大电容 C50 到 IMU | 约 2.6 mm | 15 mm,且离电池焊盘 3.4 mm |
| 每条臂的储能电容 | 没有 | 各加一颗 10 µF,离续流二极管 2.1 mm |
| ESP32 电源电容、EN 的 RC 到 1 / 2 脚 | 约 14 mm | 2.0–2.4 mm |
| 臂上栅极线与电机负端线 | 必然交叉 | 栅极、下拉电阻在臂中线一侧,漏极、二极管、电机负端焊孔在另一侧 |
| VDDA 滤波(磁珠 + 两颗电容)到 13 脚 | 约 10 mm | 1.6 mm |
| 电源芯片输入 / 输出电容到 VIN / VOUT | 4.8 / 4.8 mm | 1.9 / 1.9 mm(芯片转了 180°,电感挪到板边) |
| Flash 去耦电容到 VCC | 6.1 mm | 2.0 mm |
| 充电芯片电池侧电容到 VBAT | 7.7 mm | 2.3 mm |

主控四个 VDD 脚的 100 nF 都在 2.1–2.6 mm 内。还偏远的:复位脚的电容 7 mm(不敏感)、
充电芯片输入电容 4.2 mm、IMU 的两颗电容 3.6 mm。

臂上的电池正极要从二极管一侧绕到焊孔一侧,顶层过不去,需要走内层(L3)。

## 摆位上已知的妥协

- **IMU 紧挨无线模块的后沿**(约 3 mm)。Bosch 建议 IMU 远离发热器件,但在 40 mm 的板上两者都要靠近中线,没有更好的位置。
- **气压计离主控和板边都不远**,手册建议远离热源和板边。
- **无线模块两侧 5 mm 内有 Flash 和指示灯**。厂家建议天线周围 15 mm 净空,这块板做不到。
- **电机座没有打印验证过**。配合间隙要试打后再调;定位孔边上只剩约 0.9 mm 的板材,偏薄。
- **没有安装孔和定位孔**,也没有电池的固定结构。

## 下一步由你来做的

1. 用 KiCad 打开 `fc_v1/fc_v1.kicad_pcb`,先看一遍摆位,不满意的直接拖。
2. 设置叠层:L1 信号、L2 完整地平面、L3 电源(3.3 V 和电池各一块)、L4 信号加铺地。
3. 先布电源和电机的粗线,再布 USB、晶振、SPI,最后是其余信号。
4. 铺铜,打地过孔,整理丝印。
5. 跑 DRC。把板子文件给我,我可以再做一遍检查和审查。

## 还没做的

- 外接模块的型号没定;电池和模块的固定托架没设计。
- 物料清单、价格和板厂可贴片型号的核对。
- USB 口的防静电器件、电池反接和过放保护。

Parts:
C1, C3, C4, C40, C43, C44, C52, C53, C54, C55: 10uF; C_0603_1608Metric
C2, C5, C10, C11, C12, C13, C16, C19, C22, C30, C31, C32, C35, C36, C41: 100nF; C_0402_1005Metric
C6, C7, C14: 4.7uF; C_0603_1608Metric
C15, C42: 1uF; C_0402_1005Metric
C17, C18: 2.2uF; C_0402_1005Metric
C20, C21: 12pF; C_0402_1005Metric
C50, C51: 47uF; C_1206_3216Metric
D1: CHG; LED_0603_1608Metric
D2: BLUE; LED_0603_1608Metric
D3: RED; LED_0603_1608Metric
D11, D12, D13, D14: SS14-class; D_SOD-323
FB1: 600R@100MHz; L_0603_1608Metric
J1: BATT 1S; SolderWire-0.25sqmm_1x02_P4.2mm_D0.65mm_OD1.7mm
J2: USB-C; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J3: MOTOR1; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm
J4: MOTOR2; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm
J5: MOTOR3; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm
J6: MOTOR4; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm
J7: SWD; PinHeader_1x06_P1.27mm_Vertical_SMD_Pin1Left
J8: EXT; JST_SH_SM08B-SRSS-TB_1x08-1MP_P1.00mm_Horizontal
J9: FLOW SPI/I2C; JST_SH_SM08B-SRSS-TB_1x08-1MP_P1.00mm_Horizontal
J10: FLOW UART; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
L1: 2.2uH Isat>=2A; L_1008_2520Metric
L2: 4.7uH Isat>=0.5A; L_1008_2520Metric
Q1, Q2, Q3, Q4: AO3400A; SOT-23
R1, R2, R15: 100k; R_0402_1005Metric
R3, R4: 5.1k; R_0402_1005Metric
R5: 3.9k; R_0402_1005Metric
R6, R11, R12: 1k; R_0402_1005Metric
R7, R9, R10, R14, R30, R31, R32, R33, R34, R35, R36, R41, R42, R43, R44: 10k; R_0402_1005Metric
R8: 20k; R_0402_1005Metric
R13: 100R; R_0402_1005Metric
R20, R21: 2.2k; R_0402_1005Metric
R37, R38, R39: 33R; R_0402_1005Metric
SW1: POWER; SW_SPDT_PCM12
SW2: BOOT; SW_Push_1P1T_NO_CK_KMR2
U1: STM32F405RGT6; LQFP-64_10x10mm_P0.5mm
U2: TPS63001; Texas_DRC0010J
U3: MCP73831-2; SOT-23-5
U4: BMI088; Bosch_LGA-16_4.5x3mm_P0.5mm_LayoutBorder7x1y_ClockwisePinNu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
U5: BMP280; Bosch_LGA-8_2x2.5mm_P0.65mm_ClockwisePinNumbering
U7: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm
U8: ESP32-C3-WROOM-02
U9: TPS61222; Texas_R-PDSO-G6
Y1: 8MHz CL=10pF; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C3.1, C4.1, C10.1, C11.1, C12.1, C13.1, C14.1, C22.1, C30.1, C31.1, C32.1, C35.1, C36.1, C40.1, C41.1, FB1.1, J7.1, J8.2, J9.1, R20.1, R21.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1, R36.1, SW2.1, U1.1 (VBAT), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.1 (VOUT), U2.10 (FB), U4.3 (VDD), U4.11 (VDDIO), U5.2 (CSB), U5.6 (VDDIO), U5.8 (VDD), U7.8 (VCC), U8.1 (3V3)
+3V3A: C15.1, C16.1, FB1.2, U1.13 (VDDA)
+5V: C44.1, J10.1, U9.2 (FB), U9.4 (VOUT)
+BATT: C1.1, C7.1, C43.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), J1.1, J3.1, J4.1, J5.1, J6.1, J8.1, L2.1, R1.1, R13.1, U2.5 (VIN), U3.3 (V_{BAT}), U9.1 (VIN)
BOOST_EN: R15.1, U1.29 (PB10), U9.6 (EN)
BOOST_L: L2.2, U9.5 (L)
BOOT0: R9.1, SW2.2, U1.60 (BOOT0)
BOOT1: R10.1, U1.28 (PB2)
CHG_LED_A: D1.2 (A), R6.2
CHG_PROG: R5.1, U3.5 (PROG)
CHG_STAT: D1.1 (K), U3.1 (STAT)
ESP_BOOT: R34.2, U1.41 (PA8), U8.8 (IO9)
ESP_EN: C42.1, R30.2, U1.11 (PC3), U8.2 (EN)
ESP_IO2: R32.2, U8.16 (IO2)
ESP_IO8: R31.2, U8.7 (IO8)
ESP_RX: U1.16 (PA2), U8.11 (IO20/RXD)
ESP_TX: U1.17 (PA3), U8.12 (IO21/TXD)
EXT_IO: J8.7, U1.27 (PB1)
EXT_RX: J8.4, U1.15 (PA1)
EXT_TX: J8.3, U1.14 (PA0)
FLASH_CS: R33.2, U1.33 (PB12), U7.1 (~CS)
FLASH_HOLD: R36.2, U7.7 (~HOLD/~RESET/IO_{3})
FLASH_WP: R35.2, U7.3 (~WP/IO_{2})
FLOW_CS: J9.5, U1.8 (PC0)
FLOW_MISO: J9.3, R38.2
FLOW_MOSI: J9.4, R39.2
FLOW_SCK: J9.2, R37.2
FLOW_URX: J10.3, U1.54 (PD2)
FLOW_UTX: J10.2, U1.53 (PC12)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C30.2, C31.2, C32.2, C35.2, C36.2, C40.2, C41.2, C42.2, C43.2, C44.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, D2.1 (K), D3.1 (K), J1.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), J7.6, J8.8, J9.8, J10.4, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R2.2, R3.2, R4.2, R5.2, R8.2, R9.2, R10.2, R14.2, R15.2, R41.2, R42.2, R43.2, R44.2, SW1.3 (C), U1.12 (VSSA), U1.18 (VSS), U1.63 (VSS), U2.3 (PGND), U2.9 (GND), U2.11 (PGND), U3.2 (V_{SS}), U4.2 (GNDA), U4.4 (GNDA), U4.6 (GNDIO), U4.7 (PS), U5.1 (GND), U5.5 (SDO), U5.7 (GND), U7.4 (GND), U8.9 (GND), U8.19 (GND), U9.3 (GND), Y1.2 (G), Y1.4 (G)
I2C1_SCL: J8.5, J9.6, R20.2, U1.58 (PB6), U5.4 (SCK)
I2C1_SDA: J8.6, J9.7, R21.2, U1.59 (PB7), U5.3 (SDI)
IMU_CS_ACC: U1.20 (PA4), U4.14 (~CSB1)
IMU_CS_GYR: U1.24 (PC4), U4.5 (~CSB2)
IMU_INT_ACC: U1.25 (PC5), U4.16 (INT1)
IMU_INT_GYR: U1.26 (PB0), U4.12 (INT3)
LED1: R11.1, U1.56 (PB4)
LED1_A: D2.2 (A), R11.2
LED2: R12.1, U1.57 (PB5)
LED2_A: D3.2 (A), R12.2
MOTOR1_N: D11.2 (A), J3.2, Q1.3 (D)
MOTOR1_PWM: Q1.1 (G), R41.1, U1.37 (PC6)
MOTOR2_N: D12.2 (A), J4.2, Q2.3 (D)
MOTOR2_PWM: Q2.1 (G), R42.1, U1.38 (PC7)
MOTOR3_N: D13.2 (A), J5.2, Q3.3 (D)
MOTOR3_PWM: Q3.1 (G), R43.1, U1.39 (PC8)
MOTOR4_N: D14.2 (A), J6.2, Q4.3 (D)
MOTOR4_PWM: Q4.1 (G), R44.1, U1.40 (PC9)
NRST: C19.1, J7.5, U1.7 (NRST)
OSC_IN: C20.1, U1.5 (PH0), Y1.1
OSC_OUT: C21.1, U1.6 (PH1), Y1.3
PA10_PD: R14.1, U1.43 (PA10)
REG_EN: SW1.2 (B), U2.6 (EN)
REG_L1: L1.1, U2.4 (L1)
REG_L2: L1.2, U2.2 (L2)
REG_VINA: C2.1, R13.2, SW1.1 (A), U2.7 (PS/SYNC), U2.8 (VINA)
SPI1_MISO: U1.22 (PA6), U4.10 (SDO2), U4.15 (SDO1)
SPI1_MOSI: U1.23 (PA7), U4.9 (SDI/SDA)
SPI1_SCK: U1.21 (PA5), U4.8 (SCK/SCL)
SPI2_MISO: R38.1, U1.35 (PB14), U7.2 (DO/IO_{1})
SPI2_MOSI: R39.1, U1.36 (PB15), U7.5 (DI/IO_{0})
SPI2_SCK: R37.1, U1.34 (PB13), U7.6 (CLK)
SWCLK: J7.3, U1.49 (PA14)
SWDIO: J7.2, U1.46 (PA13)
SWO: J7.4, U1.55 (PB3)
USB_CC1: J2.A5 (CC1), R3.1
USB_CC2: J2.B5 (CC2), R4.1
USB_DM: J2.A7 (D-), J2.B7 (D-), U1.44 (PA11)
USB_DP: J2.A6 (D+), J2.B6 (D+), U1.45 (PA12)
USB_VBUS_SENSE: R7.2, R8.1, U1.42 (PA9)
VBAT_SENSE: C5.1, R1.2, R2.1, U1.10 (PC2)
VBUS: C6.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R6.1, R7.1, U3.4 (V_{DD})
VCAP_1: C17.1, U1.31 (VCAP_1)
VCAP_2: C18.1, U1.47 (VCAP_2)

Notes on the sheet:
电源:1S 锂电 → TPS63001 升降压 → 3.3 V(开关只控制使能脚,不走大电流)
USB-C 与充电 MCP73831(约 250 mA)
主控 STM32F405RGT6(168 MHz,带 FPU)
IMU BMI088(SPI1)
气压计 BMP280(I2C1,地址 0x76)
日志 Flash W25Q128(SPI2)
无线 ESP32-C3(串口桥)
有刷电机驱动 ×4:N 沟道 MOS 低边开关 + 续流二极管 + 栅极下拉
调试 SWD
扩展口
模块口 A:SPI + I2C
口 B:串口 + 5 V
5 V 升压 TPS61222(只给口 B 的模块用,默认关闭)
PWR_FLAG:仅供 ERC 识别电源来源

Board: 4 copper layers, 102 parts (4 on the bottom side), 74 nets, no tracks yet.

## Code that names these connections

File hardware/fc_v1.py (part):

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cap("C3", "10uF", 109.22, 86.36, "+3V3", fp=C0603)
cap("C4", "10uF", 119.38, 86.36, "+3V3", fp=C0603)
# 电池电压检测:1/2 分压进 ADC
res("R1", "100k", 132.08, 38.1, "+BATT", "VBAT_SENSE|nolabel")
res("R2", "100k", 132.08, 50.8, "VBAT_SENSE|right", "GND")
cap("C5", "100nF", 149.86, 50.8, "VBAT_SENSE")

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cap("C7", "4.7uF", 109.22, 160.02, "+BATT", fp=C0603)
res("R6", "1k", 58.42, 160.02, "VBUS", "CHG_LED_A")
s.place("Device:LED", "D1", "CHG", 78.74, 182.88, {"A": "CHG_LED_A", "K": "CHG_STAT"}, footprint=LED0603)
res("R7", "10k", 119.38, 160.02, "VBUS", "USB_VBUS_SENSE|nolabel")       # VBUS 检测,分压到 3.3 V 以内
res("R8", "20k", 119.38, 172.72, "USB_VBUS_SENSE|right", "GND")

# ============================ 主控 STM32F405RG ============================
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s.place("MCU_ST_STM32F4:STM32F405RGTx", "U1", "STM32F405RGT6", 205.74, 142.24, {
    "VBAT": "+3V3", "VDD": "+3V3", "VDDA": "+3V3A", "VSS": "GND", "VSSA": "GND",
    "VCAP_1": "VCAP_1", "VCAP_2": "VCAP_2", "NRST": "NRST", "BOOT0": "BOOT0",
    "PH0": "OSC_IN", "PH1": "OSC_OUT",
    "PA0": "EXT_TX", "PA1": "EXT_RX",                        # UART4:外部定位/摄像头模块
    "PA2": "ESP_RX", "PA3": "ESP_TX",                        # USART2:ESP32-C3 无线桥
    "PA4": "IMU_CS_ACC", "PA5": "SPI1_SCK", "PA6": "SPI1_MISO", "PA7": "SPI1_MOSI",
    "PA8": "ESP_BOOT", "PA9": "USB_VBUS_SENSE", "PA10": "PA10_PD", "PA11": "USB_DM", "PA12": "USB_DP",
    "PA13": "SWDIO", "PA14": "SWCLK",
    "PB0": "IMU_INT_GYR", "PB1": "EXT_IO", "PB2": "BOOT1", "PB3": "SWO",
    "PB4": "LED1", "PB5": "LED2", "PB6": "I2C1_SCL", "PB7": "I2C1_SDA",
    "PB12": "FLASH_CS", "PB13": "SPI2_SCK", "PB14": "SPI2_MISO", "PB15": "SPI2_MOSI",
    "PC0": "FLOW_CS", "PC2": "VBAT_SENSE", "PC3": "ESP_EN",
    "PC12": "FLOW_UTX", "PD2": "FLOW_URX", "PB10": "BOOST_EN",     # UART5:串口类光流模块;PB10 控制 5 V 升压
    "PC4": "IMU_CS_GYR", "PC5": "IMU_INT_ACC",
    "PC6": "MOTOR1_PWM", "PC7": "MOTOR2_PWM", "PC8": "MOTOR3_PWM", "PC9": "MOTOR4_PWM",   # TIM3 CH1-4
}, nc=("PA15", "PB8", "PB9", "PB11", "PC1", "PC10", "PC11", "PC13", "PC14", "PC15"))
for i in range(4):
    cap(f"C{10 + i}", "100nF", 162.56 + 10.16 * i, 50.8, "+3V3")
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cap("C19", "100nF", 137.16, 91.44, "NRST")
res("R9", "10k", 149.86, 91.44, "BOOT0", "GND")
res("R10", "10k", 162.56, 91.44, "BOOT1", "GND")
res("R14", "10k", 175.26, 91.44, "PA10_PD", "GND")       # PA10 是下载程序的串口输入脚,不能悬空
s.place("Switch:SW_Push", "SW2", "BOOT", 149.86, 71.12, {"1": "+3V3", "2": "BOOT0"},
        footprint="Button_Switch_SMD:SW_Push_1P1T_NO_CK_KMR2")
s.place("Device:Crystal_GND24", "Y1", "8MHz CL=10pF", 149.86, 116.84, {"1": "OSC_IN", "3": "OSC_OUT", "G": "GND"},
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    nc=("IO0", "IO1", "IO3", "IO4", "IO5", "IO6", "IO7", "IO10", "IO18", "IO19"))
cap("C40", "10uF", 355.6, 180.34, "+3V3", fp=C0603)
cap("C41", "100nF", 365.76, 180.34, "+3V3")
res("R30", "10k", 375.92, 180.34, "+3V3", "ESP_EN|nolabel")
cap("C42", "1uF", 375.92, 193.04, "ESP_EN|right")
res("R31", "10k", 388.62, 180.34, "+3V3", "ESP_IO8")           # 启动配置脚,需上拉
res("R32", "10k", 398.78, 180.34, "+3V3", "ESP_IO2")           # 启动配置脚,需上拉
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